# Keil uVision project Joystick.uvprojx, settings and files
target USB-Stick (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Joystick +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c USBD_User_HID_0.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, USB:CORE 6.9.0, USB:Device 6.9.0, USB:Device:HID 6.9.0, CMSIS Driver:USART 2.2, CMSIS Driver:USB Device 2.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
